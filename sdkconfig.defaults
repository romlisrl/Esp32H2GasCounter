## sdkconfig.defaults
```kconfig
# Overrides that must survive idf.py set-target / fullclean
# ESP32H2 with 4MB flash

CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="4MB"
```
